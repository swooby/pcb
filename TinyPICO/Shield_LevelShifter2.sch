File: TinyPICO/Shield_LevelShifter2.sch (EAGLE design)
At the start: 14 parts, among them U4 SN74HCT245DBRDB20-M

Commit message: Checkpoint
Parts:
- renumbered C2 to C1, R5 to R1, U4 to U1
